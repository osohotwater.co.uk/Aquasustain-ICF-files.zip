Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: EH-200 Pro RF
Time: 2025-10-23T15:15:50+02:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v18.104
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 10027448_2 (4)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: 10092606_1 (6)
In: Default Building
empty property set name - PartNumber: 10092606

# IfcBuildingElementProxy: 16008_6 (2)
In: Default Building
empty property set name - PartNumber: 16008

# IfcBuildingElementProxy: 16009_4 (2)
In: Default Building
empty property set name - PartNumber: 16009

# IfcBuildingElementProxy: 16011_1 (2)
In: Default Building
empty property set name - PartNumber: 16011

# IfcBuildingElementProxy: 16454_1 (2)
In: Default Building
empty property set name - PartNumber: 16454

# IfcBuildingElementProxy: 20003_1 (2)
In: Default Building
empty property set name - PartNumber: 20003

# IfcBuildingElementProxy: 20004_4
In: Default Building
empty property set name - PartNumber: 20004

# IfcBuildingElementProxy: 20010_3
In: Default Building
empty property set name - PartNumber: 20010

# IfcBuildingElementProxy: 20012_3
In: Default Building
empty property set name - PartNumber: 20012

# IfcBuildingElementProxy: 20015_2
In: Default Building
empty property set name - PartNumber: 20015

# IfcBuildingElementProxy: 20016_3
In: Default Building
empty property set name - PartNumber: 20016

# IfcBuildingElementProxy: 20018_4
In: Default Building
empty property set name - PartNumber: 20018

# IfcBuildingElementProxy: 20019_3
In: Default Building
empty property set name - PartNumber: 20019

# IfcBuildingElementProxy: 2ESDV-02P
In: Default Building
empty property set name - PartNumber: 2ESDV-02P

# IfcBuildingElementProxy: 5ESDG-06P
In: Default Building
empty property set name - PartNumber: 5ESDG-06P

# IfcBuildingElementProxy: 5ESDG-07P
In: Default Building
empty property set name - PartNumber: 5ESDG-07P

# IfcBuildingElementProxy: 90009_3 (2)
In: Default Building
empty property set name - PartNumber: 90009

# IfcBuildingElementProxy: AISLANTE_COIMP_1
In: Default Building
empty property set name - PartNumber: AISLANTE_COIMP

# IfcBuildingElementProxy: AISLANTE_COMP_PROPANO
In: Default Building
empty property set name - PartNumber: AISL_COMP_PROPANO

# IfcBuildingElementProxy: AISL_FRONT_EH v2_1
In: Default Building
empty property set name - PartNumber: AISL_FRONT_EH v2

# IfcBuildingElementProxy: AISL_LAT_ECOHEAT (2)
In: Default Building
empty property set name - PartNumber: AISL_LAT_ECOHEAT

# IfcBuildingElementProxy: BANDEJA EPP-ECOHEAT.v8 (2)
In: Default Building
empty property set name - PartNumber: BANDEJA EPP-ECOHEAT

# IfcBuildingElementProxy: BN 31202 5401662 hex nut M10x1_Brass (2)
In: Default Building
empty property set name - PartNumber: BN 31202 5401662 hex nut M10x1

# IfcBuildingElementProxy: Bateria 430 x 325 x 43.3
In: Default Building
empty property set name - PartNumber: Bateria 430 x 325 x 43.3

# IfcBuildingElementProxy: CABEZA ROSCA RESISTENCIA_1
In: Default Building
empty property set name - PartNumber: RESISTENCIA 1500W

# IfcBuildingElementProxy: CAPILAR1_1
In: Default Building
empty property set name - PartNumber: CAPILAR1

# IfcBuildingElementProxy: CAPILAR2 _1
In: Default Building
empty property set name - PartNumber: CAPILAR2

# IfcBuildingElementProxy: CIERRE INTERIOR AIRE EH-RF_2
In: Default Building
empty property set name - PartNumber: CIERRE INTERIOR AIRE EH-RF

# IfcBuildingElementProxy: CLIP PERNO COMPRESOR_1 (2)
In: Default Building
empty property set name - PartNumber: CLIP PERNO COMPRESOR

# IfcBuildingElementProxy: COLECTOR 9.52X165mm
In: Default Building
empty property set name - PartNumber: COLECTOR 12X165mm

# IfcBuildingElementProxy: CONDENSADOR ARRANQUE 1.8mF (4)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: CONDENSADOR ARRANQUE 25mF (2)
In: Default Building
empty property set name - PartNumber: 86284

# IfcBuildingElementProxy: CONQUILLA ENTRADA_COND_1
In: Default Building
empty property set name - PartNumber: CONQUILLA ENTRADA_COND

# IfcBuildingElementProxy: CONQUILLA SALIDA_COND_1
In: Default Building
empty property set name - PartNumber: CONQUILLA SALIDA_COND

# IfcBuildingElementProxy: COQUILLA ASPI R290_1
In: Default Building
empty property set name - PartNumber: COQUILLA ASPI R290

# IfcBuildingElementProxy: COQUILLA ASP_1
In: Default Building
empty property set name - PartNumber: COQUILLA ASP

# IfcBuildingElementProxy: COQUILLA BAJA EH PRO_1
In: Default Building
empty property set name - PartNumber: COQUILLA BAJA EH PRO

# IfcBuildingElementProxy: CUBA DEP180L-RF_1
In: Default Building
empty property set name - PartNumber: 1-DEP180L

# IfcBuildingElementProxy: Codo 25mm (45)
In: Default Building
Name | PartNumber
22 x Codo 25mm | CODO 90Âº 1_4 L=25
23 x Codo 25mm | CODO 90Âº Ã˜7 L=25

# IfcBuildingElementProxy: EMBELLECEDOR 1-2in_1
In: Default Building
empty property set name - PartNumber: EMBELLECEDOR 1-2in

# IfcBuildingElementProxy: EMBELLECEDOR 3-4in_1 (3)
In: Default Building
empty property set name - PartNumber: EMBELLECEDOR 3-4in

# IfcBuildingElementProxy: FILTRO PARTÍCULAS_1
In: Default Building
empty property set name - PartNumber: 99635

# IfcBuildingElementProxy: HPS450350
In: Default Building
empty property set name - PartNumber: HPS450350

# IfcBuildingElementProxy: LINEA FILTRO 1-4´´EH PRO_1
In: Default Building
empty property set name - PartNumber: LINEA FILTRO 1-4Â´Â´EH PRO

# IfcBuildingElementProxy: LPS0520
In: Default Building
empty property set name - PartNumber: LPS0520

# IfcBuildingElementProxy: Pasacables deformado_1 (2)
In: Default Building
empty property set name - PartNumber: Pasacables deformado

# IfcBuildingElementProxy: Perfil lateral_01
In: Default Building
empty property set name - PartNumber: lateral derecho

# IfcBuildingElementProxy: Perfil lateral_dcho
In: Default Building
empty property set name - PartNumber: lateral derecho

# IfcBuildingElementProxy: Perfil lateral_izq (2)
In: Default Building
Name | PartNumber
Perfil lateral_izq | Lateral izq
Perfil lateral_izq | Lateral izquierdo

# IfcBuildingElementProxy: Perno compresor ESPECIAL BANDEJA EPP (2)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: Perno compresor ESPECIAL BANDEJA EPP - v2 (4)
In: Default Building
empty property set name - PartNumber: PERNO COMPRESOR ESPECIAL BANDEJA EPP v2

# IfcBuildingElementProxy: RFGB06-0.35-6801-RK _0
In: Default Building
empty property set name - PartNumber: RFGB06-0.35-6801-RK

# IfcBuildingElementProxy: Raised head screw DIN 7985 M4x6-Z 24662_040_006(High) (19)
In: Default Building
empty property set name - PartNumber: Raised head screw DIN 7985 M4x6-Z 24662.040.006(High)

# IfcBuildingElementProxy: SJSCP6A (4)
In: Default Building
empty property set name - PartNumber: SJSCP6A

# IfcBuildingElementProxy: SV01_3
In: Default Building
empty property set name - PartNumber: SV01

# IfcBuildingElementProxy: Serpentin condensador VIDEIRA_1
In: Default Building
empty property set name - PartNumber: Serpentin condensador VIDEIRA

# IfcBuildingElementProxy: TAPA FRENTE LISO RF_1
In: Default Building
empty property set name - PartNumber: TAPA FRENTE LISO RF

# IfcBuildingElementProxy: TAPÓN_1 (2)
In: Default Building
empty property set name - PartNumber: TAPÃ“N

# IfcBuildingElementProxy: TERMOSTATO SEGURIDAD_1 (2)
In: Default Building
empty property set name - PartNumber: TERMOSTATO SEGURIDAD

# IfcBuildingElementProxy: TRAMO 1_4 A VALVULA SOLENOIDE EH_1
In: Default Building
empty property set name - PartNumber: TRAMO 1_4 A VALVULA SOLENOIDE EH

# IfcBuildingElementProxy: TRAMO 2 SALID SERP EH_1
In: Default Building
empty property set name - PartNumber: TRAMO 2 SALID SERP EH

# IfcBuildingElementProxy: TRAMO 3-8´´ ENTRADA_1
In: Default Building
empty property set name - PartNumber: TRAMO 3-8Â´Â´ ENTRADA

# IfcBuildingElementProxy: TRAMO ALTA-VAL SOLE PROPANO_1
In: Default Building
empty property set name - PartNumber: TRAMO ALTA-VAL SOLE PROPANO

# IfcBuildingElementProxy: TRAMO LINEA 2-VALVULA SOLEN._1
In: Default Building
empty property set name - PartNumber: TRAMO LINEA 2-VALVULA SOLEN.

# IfcBuildingElementProxy: TRAMO SALIDA SERP EH _1
In: Default Building
empty property set name - PartNumber: TRAMO SALIDA SERP EH

# IfcBuildingElementProxy: TUB BAJA-VALV. SOLENOI EH PROP_1
In: Default Building
empty property set name - PartNumber: TUB BAJA-VALV. SOLENOI EH PROP

# IfcBuildingElementProxy: TUB ENTRA BAT_R290_1
In: Default Building
empty property set name - PartNumber: TUB ENTRA BAT_R290

# IfcBuildingElementProxy: TUB1-SALD_1
In: Default Building
empty property set name - PartNumber: TUB1-SALD

# IfcBuildingElementProxy: TUB1_ENTRADA_1
In: Default Building
empty property set name - PartNumber: TUB1_ENTRADA

# IfcBuildingElementProxy: TUBERÍA ALTA 2 EH_1
In: Default Building
empty property set name - PartNumber: TUBERÃA ALTA 2 EH

# IfcBuildingElementProxy: TUBERÍA ALTA 3_EH_1
In: Default Building
empty property set name - PartNumber: TUBERÃA ALTA 3_EH

# IfcBuildingElementProxy: TUBERÍA ASPIRACIÓN_1
In: Default Building
empty property set name - PartNumber: TUBERÃA ASPIRACIÃN

# IfcBuildingElementProxy: TUBERÍA LINEA ALTA EH_1
In: Default Building
empty property set name - PartNumber: TUBERÃA LINEA ALTA EH

# IfcBuildingElementProxy: TUBO 1_4 11mm (4)
In: Default Building
empty property set name - PartNumber: TUBO 1_4 11mm

# IfcBuildingElementProxy: TUBO 7x11mm (2)
In: Default Building
empty property set name - PartNumber: TUBO Ã˜7x11mm

# IfcBuildingElementProxy: TUB_ASPIRA_R290_1
In: Default Building
empty property set name - PartNumber: TUB_ASPIRA_R290

# IfcBuildingElementProxy: TUB_DESCARGA EH-R290_1
In: Default Building
empty property set name - PartNumber: TUB_DESCARGA EH-R290

# IfcBuildingElementProxy: TUB_ENTR_1
In: Default Building
empty property set name - PartNumber: TUB_ENTR

# IfcBuildingElementProxy: TUB_SAL_1
In: Default Building
empty property set name - PartNumber: TUB_SAL

# IfcBuildingElementProxy: Tapa Ecoheat Aerotermia 160-200-260 - Joule_3
In: Default Building
empty property set name - PartNumber: Tapa Ecoheat Aerotermia 160-200-260 - Joule

# IfcBuildingElementProxy: Tapping screw DIN 7982 ST4_2x13-C-H 26680_042_013(High) (30)
In: Default Building
empty property set name - PartNumber: Tapping screw DIN 7982 ST4.2x13-C-H 26680.042.013(High)

# IfcBuildingElementProxy: VENTESTPZ1_2 (2)
In: Default Building
empty property set name - PartNumber: VENTESTPZ1

# IfcBuildingElementProxy: VENTESTPZ2RE_2 (2)
In: Default Building
empty property set name - PartNumber: VENTESTPZ2RE

# IfcBuildingElementProxy: VENTILADOR 1V_1
In: Default Building
empty property set name - PartNumber: VENTILADOR 1V

# IfcBuildingElementProxy: VIROLA INF DEP180L-RF_1
In: Default Building
empty property set name - PartNumber: VIROLA INF DEP180LRF

# IfcBuildingElementProxy: VIROLA SUP DEP100L_1
In: Default Building
empty property set name - PartNumber: VIROLA CalderÃ­n 100L

# IfcBuildingElementProxy: Válvula solenoide 90º (2)
In: Default Building
empty property set name - PartNumber: 10120006501

# IfcBuildingElementProxy: WUERTH 094820 05 rivet nut M5 A2K_Steel (4)
In: Default Building
empty property set name - PartNumber: WUERTH 094820 05 rivet nut M5 A2K

# IfcBuildingElementProxy: YK01L-479-02G035G
In: Default Building
empty property set name - PartNumber: YK01L-479-02G035G

# IfcBuildingElementProxy: YK03H-4118-25R20R
In: Default Building
empty property set name - PartNumber: YK03H-4118-25R20R

# IfcBuildingElementProxy: emile_maurin_347914,8X16 (18)
In: Default Building
empty property set name - PartNumber: emile_maurin_347914,8X16

# IfcBuildingElementProxy: tapa delantera EH
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: tapa inferior frente RF_1
In: Default Building
empty property set name - PartNumber: tapa inferior frente RF
