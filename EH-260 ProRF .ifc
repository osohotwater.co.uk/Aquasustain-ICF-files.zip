Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: EH-260RF
Time: 2025-03-26T14:54:54+01:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v18.104
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 10027448_2 (2)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: 10092606_1 (3)
In: Default Building
empty property set name - PartNumber: 10092606

# IfcBuildingElementProxy: 16008_6
In: Default Building
empty property set name - PartNumber: 16008

# IfcBuildingElementProxy: 16009_4
In: Default Building
empty property set name - PartNumber: 16009

# IfcBuildingElementProxy: 16011_1
In: Default Building
empty property set name - PartNumber: 16011

# IfcBuildingElementProxy: 20004_4
In: Default Building
empty property set name - PartNumber: 20004

# IfcBuildingElementProxy: 26003_1 (2)
In: Default Building
empty property set name - PartNumber: 26003

# IfcBuildingElementProxy: 26016_3
In: Default Building
empty property set name - PartNumber: 26016

# IfcBuildingElementProxy: 26021_5
In: Default Building
empty property set name - PartNumber: 26021

# IfcBuildingElementProxy: 26022_4
In: Default Building
empty property set name - PartNumber: 26022

# IfcBuildingElementProxy: 2ESDV-02P
In: Default Building
empty property set name - PartNumber: 2ESDV-02P

# IfcBuildingElementProxy: 5ESDG-06P
In: Default Building
empty property set name - PartNumber: 5ESDG-06P

# IfcBuildingElementProxy: 5ESDG-07P
In: Default Building
empty property set name - PartNumber: 5ESDG-07P

# IfcBuildingElementProxy: 90009_3
In: Default Building
empty property set name - PartNumber: 90009

# IfcBuildingElementProxy: AISLANTE_COMP_PROPANO
In: Default Building
empty property set name - PartNumber: AISL_COMP_PROPANO

# IfcBuildingElementProxy: BANDEJA EPP-ECOHEAT.v8
In: Default Building
empty property set name - PartNumber: BANDEJA EPP-ECOHEAT

# IfcBuildingElementProxy: BN 31202 5401662 hex nut M10x1_Brass
In: Default Building
empty property set name - PartNumber: BN 31202 5401662 hex nut M10x1

# IfcBuildingElementProxy: Bateria 430 x 325 x 43.3
In: Default Building
empty property set name - PartNumber: Bateria 430 x 325 x 43.3

# IfcBuildingElementProxy: CABEZA ROSCA RESISTENCIA_1
In: Default Building
empty property set name - PartNumber: RESISTENCIA 1500W

# IfcBuildingElementProxy: CABLE AMARILLO FAN2-2V
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE AZUL FAN2-2V
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE BLANCO F2-2V
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE BLANCO NTC1
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE NEGRO F2-2V
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE NEGRO1-NTC1
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLE NEGRO2-NTC1
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLEADO BLANCO HPS
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLEADO NEGRO1 HPS
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CABLEADO NEGRO2 HPS
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: CLIP PERNO COMPRESOR_1
In: Default Building
empty property set name - PartNumber: CLIP PERNO COMPRESOR

# IfcBuildingElementProxy: CONDENSADOR ARRANQUE 1.8mF (2)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: CONDENSADOR ARRANQUE 25mF
In: Default Building
empty property set name - PartNumber: 86284

# IfcBuildingElementProxy: CONQUILLA ENTRADA_COND_1
In: Default Building
empty property set name - PartNumber: CONQUILLA ENTRADA_COND

# IfcBuildingElementProxy: CONQUILLA SALIDA_COND_1
In: Default Building
empty property set name - PartNumber: CONQUILLA SALIDA_COND

# IfcBuildingElementProxy: COQUILLA ASPI R290_1
In: Default Building
empty property set name - PartNumber: COQUILLA ASPI R290

# IfcBuildingElementProxy: COQUILLA BAJA EH PRO_1
In: Default Building
empty property set name - PartNumber: COQUILLA BAJA EH PRO

# IfcBuildingElementProxy: CUBA DEP245L-RF_1
In: Default Building
empty property set name - PartNumber: 1-DEP245L

# IfcBuildingElementProxy: Codo 25mm (23)
In: Default Building
empty property set name - PartNumber: CODO 90Âº Ã˜7 L=25

# IfcBuildingElementProxy: EMBELLECEDOR 1-2in_1 (2)
In: Default Building
empty property set name - PartNumber: EMBELLECEDOR 1-2in

# IfcBuildingElementProxy: EMBELLECEDOR 3-4in_1 (3)
In: Default Building
empty property set name - PartNumber: EMBELLECEDOR 3-4in

# IfcBuildingElementProxy: LINEA FILTRO 1-4´´EH PRO_1
In: Default Building
empty property set name - PartNumber: LINEA FILTRO 1-4Â´Â´EH PRO

# IfcBuildingElementProxy: Pasacables deformado_1
In: Default Building
empty property set name - PartNumber: Pasacables deformado

# IfcBuildingElementProxy: Perfil lateral_dcho
In: Default Building
empty property set name - PartNumber: lateral derecho

# IfcBuildingElementProxy: Perfil lateral_izq
In: Default Building
empty property set name - PartNumber: Lateral izquierdo

# IfcBuildingElementProxy: Perno compresor ESPECIAL BANDEJA EPP (2)
In: Default Building
empty property set name - PartNumber: -

# IfcBuildingElementProxy: Perno compresor ESPECIAL BANDEJA EPP - v2
In: Default Building
empty property set name - PartNumber: PERNO COMPRESOR ESPECIAL BANDEJA EPP v2

# IfcBuildingElementProxy: RFGB06-0.35-6801-RK _0
In: Default Building
empty property set name - PartNumber: RFGB06-0.35-6801-RK

# IfcBuildingElementProxy: Raised head screw DIN 7985 M4x6-Z 24662_040_006(High) (10)
In: Default Building
empty property set name - PartNumber: Raised head screw DIN 7985 M4x6-Z 24662.040.006(High)

# IfcBuildingElementProxy: SJSCP6A (2)
In: Default Building
empty property set name - PartNumber: SJSCP6A

# IfcBuildingElementProxy: SV01_3
In: Default Building
empty property set name - PartNumber: SV01

# IfcBuildingElementProxy: Serpentin condensador VIDEIRA_1
In: Default Building
empty property set name - PartNumber: Serpentin condensador VIDEIRA

# IfcBuildingElementProxy: TAPA FRENTE LISO RF_1
In: Default Building
empty property set name - PartNumber: TAPA FRENTE LISO RF

# IfcBuildingElementProxy: TAPÓN_1
In: Default Building
empty property set name - PartNumber: TAPÃ“N

# IfcBuildingElementProxy: TERMOSTATO SEGURIDAD_1
In: Default Building
empty property set name - PartNumber: TERMOSTATO SEGURIDAD

# IfcBuildingElementProxy: TRAMO 2 SALID SERP EH_1
In: Default Building
empty property set name - PartNumber: TRAMO 2 SALID SERP EH

# IfcBuildingElementProxy: TRAMO 3-8´´ ENTRADA_1
In: Default Building
empty property set name - PartNumber: TRAMO 3-8Â´Â´ ENTRADA

# IfcBuildingElementProxy: TRAMO ALTA-VAL SOLE PROPANO_1
In: Default Building
empty property set name - PartNumber: TRAMO ALTA-VAL SOLE PROPANO

# IfcBuildingElementProxy: TRAMO SALIDA SERP EH _1
In: Default Building
empty property set name - PartNumber: TRAMO SALIDA SERP EH

# IfcBuildingElementProxy: TUB BAJA-VALV. SOLENOI EH PROP_1
In: Default Building
empty property set name - PartNumber: TUB BAJA-VALV. SOLENOI EH PROP

# IfcBuildingElementProxy: TUB ENTRA BAT_R290_1
In: Default Building
empty property set name - PartNumber: TUB ENTRA BAT_R290

# IfcBuildingElementProxy: TUB1-SALD_1
In: Default Building
empty property set name - PartNumber: TUB1-SALD

# IfcBuildingElementProxy: TUB1_ENTRADA_1
In: Default Building
empty property set name - PartNumber: TUB1_ENTRADA

# IfcBuildingElementProxy: TUBERÍAS ALUM SERP_1
In: Default Building
empty property set name - PartNumber: TUBERÃAS ALUM SERP

# IfcBuildingElementProxy: TUBERÍAS ENTR SERP_1
In: Default Building
empty property set name - PartNumber: TUBERÃAS ENTR SERP

# IfcBuildingElementProxy: TUBO 7x11mm (2)
In: Default Building
empty property set name - PartNumber: TUBO Ã˜7x11mm

# IfcBuildingElementProxy: TUB_ASPIRA_R290_1
In: Default Building
empty property set name - PartNumber: TUB_ASPIRA_R290

# IfcBuildingElementProxy: TUB_DESCARGA EH-R290_1
In: Default Building
empty property set name - PartNumber: TUB_DESCARGA EH-R290

# IfcBuildingElementProxy: Tapping screw DIN 7982 ST4_2x13-C-H 26680_042_013(High) (19)
In: Default Building
empty property set name - PartNumber: Tapping screw DIN 7982 ST4.2x13-C-H 26680.042.013(High)

# IfcBuildingElementProxy: VENTESTPZ1_2
In: Default Building
empty property set name - PartNumber: VENTESTPZ1

# IfcBuildingElementProxy: VENTESTPZ2RE_2
In: Default Building
empty property set name - PartNumber: VENTESTPZ2RE

# IfcBuildingElementProxy: VIROLA INF DEP180L-RF_1
In: Default Building
empty property set name - PartNumber: VIROLA INF DEP180LRF

# IfcBuildingElementProxy: VIROLA SUP DEP245L_1
In: Default Building
empty property set name - PartNumber: 2-DEP245L

# IfcBuildingElementProxy: Válvula solenoide 90º
In: Default Building
empty property set name - PartNumber: 10120006501

# IfcBuildingElementProxy: WUERTH 094820 05 rivet nut M5 A2K_Steel (2)
In: Default Building
empty property set name - PartNumber: WUERTH 094820 05 rivet nut M5 A2K

# IfcBuildingElementProxy: YK01L-479-02G035G
In: Default Building
empty property set name - PartNumber: YK01L-479-02G035G

# IfcBuildingElementProxy: YK03H-4118-25R20R
In: Default Building
empty property set name - PartNumber: YK03H-4118-25R20R

# IfcBuildingElementProxy: cable azul F2
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: cable negro F2-V1
In: Default Building
empty property set name - PartNumber: MONTAJE CAJA ELÃ‰CTRICA ECOHEAT

# IfcBuildingElementProxy: cableado azul LPS_1 (2)
In: Default Building
empty property set name - PartNumber: cableado azul LPS

# IfcBuildingElementProxy: emile_maurin_347914,8X16 (12)
In: Default Building
empty property set name - PartNumber: emile_maurin_347914,8X16
